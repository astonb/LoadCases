# Keil uVision project FHX_Proj.uvprojx, settings and files
target FHX_Proj (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FHX_Proj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1,__FPU_PRESENT=1
  c include: ..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\ads1274;..\HARDWARE\spi;..\HARDWARE\test;..\HARDWARE\gpio;..\HARDWARE\sht11;..\HARDWARE\lcd;..\HARDWARE\ad7545;..\HARDWARE\rtc;..\FreeRTOS\FreeRTOS\Source\include;..\FreeRTOS\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/spi/: spi.c
    ../HARDWARE/ads1274/: ads1274.c
    ../HARDWARE/test/: test.c
    ../HARDWARE/gpio/: gpio.c
    ../HARDWARE/sht11/: sht11.c
    ../HARDWARE/lcd/: lcd.c
    ../HARDWARE/ad7545/: ad7545.c
    ../HARDWARE/rtc/: rtc.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWILB
    ../FWLIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_fsmc.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FreeRTOS
    ../FreeRTOS/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
